File: gsa-lib.kicad_pcb (KiCad board)
At the start: 2 copper layers, 115 parts

Commit message: KiCad v10 and add RES-V
Parts:
- added Resistor or Trimmer: RES-T, GSA:RES-V, F.Cu at (124.5, 47.0)
